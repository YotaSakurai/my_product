# Repository YotaSakurai/my_product

## EAGLE design ecorun/ignition/Sakurai/ignition2/tenka1.brd

Parts:
18F14K50: 18F14K5018F14K50; 18F14K50
C1, C2, C3, C14, C15, C16, C17, C21: 0.1μF; C025-024X044
C4, C5: 50pF; C025-024X044
C11: 1μF; C025-024X044
C12, C13: 15pF; C025-024X044
C18, C19: 47μF; E2-4
C20: 2200μF; E5-13
CN1: CON_7P; CON_HRS_DIP_7
CN2: CON_9P; CON_HRS_DIP_9
CN3: CON_2P; CON_HRS_DIP_2
CN5: エンコーダ; CON_HRS_DIP_5
CN6: CON_4P; CON_HRS_DIP_4
CN7: CON_6P; CON_HRS_DIP_6
CN8レシーブ: CON_3P; CON_HRS_DIP_3
D1: 1N4004; DO41-10
DC2: DCDC_NEW
IC1: DIL28-3
LHL13NB101K1: LHL13NB101KLHL13NB101K; LHL13NB101K
Q1: CRYSTALHC49S; HC49/S
QF1: 8M10AHC49T; HC49U
R1, R2, R3, R15: 2K; 0207/7
R4: 1K; 0207/7
R5, R7, R10, R12, R13: 10K; 0207/7
R6, R14: 3.3K; 0207/7
R8, R9: 100; 0207/7
R11: R-US_0207/7; 0207/7
VR1: TRM

Connections:
+5V: 18F14K50.1 (VDD), C1.1, C4.1, C11.1, C21.1, CN5.2, CN7.1, CN8レシーブ.3, DC2.NC (VOUT+), IC1.12, IC1.20, QF1.1, R1.1, R2.1, R3.1, R7.2, R13.2, VR1.P$1
unnamed: CN5.5, IC1.11, IC1.21, R1.2
unnamed: CN2.9, R15.1
unnamed: CN6.1, IC1.28
unnamed: CN6.2, IC1.27
unnamed: CN5.4, IC1.22, R2.2
unnamed: C13.2, IC1.10, Q1.2
unnamed: C12.2, IC1.9, Q1.1
unnamed: CN7.5, IC1.18
unnamed: CN6.3, IC1.26
unnamed: CN6.4, IC1.25
unnamed: CN7.6, IC1.17
unnamed: CN7.2, VR1.P$2
unnamed: CN1.7, CN2.8, R5.2
unnamed: CN2.6, IC1.13
unnamed: 18F14K50.13 (RB4/AN10/SDI/SDA), CN1.6, CN2.7, CN3.2, R12.2
unnamed: 18F14K50.7 (RC3/AN7/P1CC12IN3-/PGM), R5.1
unnamed: 18F14K50.10 (RB7/TX/CK), CN8レシーブ.2, R7.1
unnamed: CN1.5, CN2.5, IC1.15, R8.2
unnamed: 18F14K50.8 (RC6/AN8/SS/T13CKI/T1OSCI), C5.1, QF1.3
unnamed: 18F14K50.6 (RC4/P1B/C12OUT/SRQ), C3.1, R4.2, R15.2
unnamed: CN1.3, CN2.3, R9.2
unnamed: 18F14K50.15 (RC1/AN5/C12IN1-/INT1/VREF-), C17.1, R9.1, R13.1
unnamed: 18F14K50.14 (RC2/AN6/P1D/C12IN2-/CVREF/INT2), C16.1, R8.1
unnamed: 18F14K50.16 (RC0/AN4/C12IN+/INT0/VREF+), C14.1, C15.1, R10.2, R11.1
unnamed: 18F14K50.3 (RA4/AN3/OSC2/CLKOUT), R6.2, R14.1
unnamed: C18.+, DC2.VIN- (VIN+), LHL13NB101K1.P$2
unnamed: CN1.2, CN2.2, R11.2
unnamed: C20.+, D1.C, LHL13NB101K1.P$1
unnamed: C19.+, CN1.1, CN2.1, D1.A, R6.1
unnamed: 18F14K50.20 (VSS), C1.2, C2.1, C3.2, C4.2, C5.2, C11.2, C12.1, C13.1, C14.2, C15.2, C16.2, C17.2, C18.-, C19.-, C20.-, C21.2, CN1.4, CN2.4, CN3.1, CN5.1, CN7.3, CN7.4, CN8レシーブ.1, DC2.RC, DC2.TRM (VOUT-), DC2.VIN+ (VIN-), IC1.8, IC1.19, QF1.2, R4.1, R10.1, R12.1, R14.2, VR1.P$3
unnamed: C2.2, CN5.3, IC1.23, R3.2

Notes on the sheet:
コントラスト
GND
RC7
RC6
点火用LCD
12V
ラップ
回転速度（噴射）
A/F
エンジン温度
メイン

Board: 2 copper layers, 78.8 x 62.7 mm, 46 parts (1 on the bottom side), 32 nets.

## EAGLE design ecorun/ignition/Aruga/点火未完/tennka4.brd

Parts:
C1: 1μＦ; C025-024X044
C2: 15ｐＦ; C025-024X044
C3: １５ｐＦ; C025-024X044
C4, C7, C12, C13, C16, C17, C18, C19, C20: 0.1μＦ; C025-024X044
C5, C21: 47uF; E2-4
C6: 2200uF; E5-13
C14: 50ｐＦ; C025-024X044
C15: ５０ｐＦ; C025-024X044
CN1, CN1PIKKIT2: CON_6P; CON_HRS_DIP_6
CN4　点火用ＬＣＤ: CON_4P; CON_HRS_DIP_4
CN5　エンコーダ: CON_5P; CON_HRS_DIP_5
CN7　A/F: CON_2P; CON_HRS_DIP_2
CN8　レシーブ: CON_3P; CON_HRS_DIP_3
CN１０　ロガー: CON_7P; CON_HRS_DIP_7
CN９: 配電; CON_HRS_DIP_9
D1: 1N4004; DO41-10
IC5: DIL28-3
IC6: PIC18F14K50
LHL13NB101K1: LHL13NB101K
Q1: CRYSTALHC49S; HC49/S
QF1: 8M10AHC49T; HC49U
R4, R5, R6: 10k; 0207/7
R10: 10K; 0207/7
R14: １０Ｋ; 0207/7
R16: １Ｋ; 0207/7
R18: ３．３ｋ; 0207/7
R19, R26, R29: １０ｋ; 0207/7
R23: １ｋ; 0207/7
R24, R28: 100; 0207/7
U$3: DCDC-CC3-1205SF-E
VR1, VR2, VR3: TRM

Connections:
1K: C13.1, VR1.P$3
+5V: C1.1, C4.1, C12.1, C14.1, CN1.1, CN1PIKKIT2.2, CN5 エンコーダ.2, CN8 レシーブ.3, IC5.12, IC5.20, IC6.P$1 (VDD), QF1.1, R4.2, R5.2, R6.2, R10.2, R14.2, U$3.5 (VOUT+), VR3.P$1
GND: C1.2, C2.2, C3.2, C4.2, C5.-, C6.-, C7.1, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.-, CN1.3, CN1.4, CN1PIKKIT2.3, CN5 エンコーダ.1, CN7 A/F.1, CN8 レシーブ.1, CN１０ ロガー.4, CN９.4, IC5.8, IC5.19, IC6.P$11 (VSS), QF1.2, R16.1, R26.1, R29.1, U$3.3 (RC), U$3.4 (VIN-), U$3.7 (VOUT-), VR2.P$3, VR3.P$3
unnamed: CN１０ ロガー.7, CN９.8, R19.1
unnamed: CN1PIKKIT2.1, IC5.1
unnamed: CN1PIKKIT2.4, CN4 点火用ＬＣＤ.1, IC5.28
unnamed: CN1PIKKIT2.5, CN4 点火用ＬＣＤ.2, IC5.27
unnamed: CN4 点火用ＬＣＤ.3, IC5.26
unnamed: CN4 点火用ＬＣＤ.4, IC5.25
unnamed: CN1.2, VR3.P$2
unnamed: CN1.6, IC5.17
unnamed: CN１０ ロガー.5, CN９.5, IC5.3, R28.2
unnamed: CN９.6, IC5.4
unnamed: C21.+, LHL13NB101K1.2, U$3.1 (VIN+)
unnamed: CN１０ ロガー.3, CN９.3, R24.2
unnamed: C2.1, IC5.9, Q1.1
unnamed: C3.1, IC5.10, Q1.2
unnamed: C19.1, IC6.P$17 (RC2/AN6/P1D/C121N2-/CVREF/INT2), R28.1
unnamed: C6.+, D1.C, LHL13NB101K1.1
unnamed: C7.2, CN5 エンコーダ.3, IC5.23, R6.1
unnamed: CN5 エンコーダ.4, IC5.22, R4.1
unnamed: CN5 エンコーダ.5, IC5.11, IC5.21, R5.1
unnamed: CN8 レシーブ.2, IC6.P$10 (RB7/TX/CK), R14.1
unnamed: IC6.P$7 (RC3/AN7/P1C/C12IN3/PGM), R19.2
unnamed: C15.1, IC6.P$8 (RC6/AN8/SS/T13CK/TI0SCI), QF1.3
unnamed: C16.1, IC6.P$6 (RC4/P1B/C12OUT/SRQ), R16.2, VR1.P$2
unnamed: CN1.5, IC5.18
unnamed: R18.1, VR2.P$1
unnamed: CN7 A/F.2, CN１０ ロガー.6, CN９.7, IC6.P$18 (RB4/AN10/SDI/SDA), R26.2
unnamed: C17.1, C18.1, IC6.P$15 (RC0/AN4/C12IN+/INT0/VREF+), R23.1, R29.2
unnamed: CN１０ ロガー.2, CN９.2, R23.2
unnamed: C20.1, IC6.P$16 (RC1/AN5/C12IN1-/INT1/VREF-), R10.1, R24.1
unnamed: CN９.9, VR1.P$1
unnamed: IC6.P$3 (RA4/AN3/OSC2/CLKOUT), VR2.P$2
unnamed: C5.+, CN１０ ロガー.1, CN９.1, D1.A, R18.2
RA3/MCLR/VPP: IC6.P$4 (RA3/MCLR/VPP)

Notes on the sheet:
コントラスト
GND
RC7
RC6

Board: 2 copper layers, 62.2 x 79.3 mm, 48 parts (2 on the bottom side), 35 nets.

## EAGLE design ecorun/LCD/Front_Sakurai/front.brd

Parts:
C1: CAPDIP_1; CAP_DIP_1
C2: CCAP6.5; CCAP_6.5
CN1: CON_4P; CON_HRS_DIP_4
CN2: CON_5P; CON_HRS_DIP_5
CN3, CN4: CON_2P; CON_HRS_DIP_2
D1: DIODEGENERIC_2; DIODE_2
IC1: 78LXX; TO92-VREG-78L
R1, R2: R-US_0207/7; 0207/7
X1: F09HP

Connections:
unnamed: CN1.2, X1.1
unnamed: CN1.1, X1.2
unnamed: CN2.5, R1.2, X1.3
unnamed: CN2.1, R2.2, X1.8
unnamed: CN1.3, CN1.4, X1.6, X1.7
unnamed: CN3.2, X1.9
unnamed: C1.2, CN2.4, CN4.1, D1.K, IC1.I (IN), X1.4
unnamed: C1.1, C2.+, CN2.3, CN4.2, IC1.G (GND), R1.1, R2.1, X1.5
unnamed: C2.-, CN2.2, CN3.1, D1.A, IC1.O (OUT)

Notes on the sheet:
メイン
A/Fフィールド1
A/Fフィールド2
１２V
GND
FB1
１２V
FB2
ラップカウンタ2
ホーン

Board: 2 copper layers, 90.1 x 67.0 mm, 11 parts (0 on the bottom side), 9 nets.

## EAGLE design ecorun/electronic_eq/Receive LCD/2015 Receive LCD.brd

Parts:
C1: 0.1μＦ; C025-025X050
C2, C3: 22μＦ; C025-025X050
CN2: CON_4P; CON_HRS_DIP_4
CN3: CON_6P; CON_HRS_DIP_6
CN4: CON_3P; CON_HRS_DIP_3
IC1: PIC18F14K50
Q2: CRYTALHC49U70; HC49U70
R1: 100K; 0204/7
R2: 1K; 0204/7
VR1: 1K; TRM

Connections:
DVCC: CN3.1, CN4.3, R1.2, R2.2, VR1.P$1
GND: C1.2, C2.2, C3.2, CN3.5, CN3.6, CN4.1, IC1.P$11 (VSS), VR1.P$3
unnamed: C1.1, IC1.P$1 (VDD), R1.1
unnamed: C3.1, IC1.P$3 (RA4/AN3/OSC2/CLKOUT), Q2.2
unnamed: C2.1, IC1.P$2 (RA5/OSC1/CLKIN), Q2.1
unnamed: CN2.1, IC1.P$9 (RC7/AN9/SD0/TIOSCO)
unnamed: CN3.2, IC1.P$18 (RB4/AN10/SDI/SDA)
unnamed: CN2.3, IC1.P$6 (RC4/P1B/C12OUT/SRQ)
unnamed: CN2.4, IC1.P$5 (RC5/CCP1/P1A/T0CK)
unnamed: CN2.2, IC1.P$8 (RC6/AN8/SS/T13CK/TI0SCI)
unnamed: CN3.4, IC1.P$20 (RB6/SCK/SCL)
unnamed: CN3.3, VR1.P$2
unnamed: CN4.2, IC1.P$19 (RB5/AN11/RX/DT), R2.1
RA3/MCLR/VPP: IC1.P$4 (RA3/MCLR/VPP)

Board: 2 copper layers, 54.3 x 35.5 mm, 11 parts (0 on the bottom side), 13 nets.

## EAGLE design ecorun/LCD/回路図/Logger.brd

Parts:
C1, C2: 22pF; C025-024X044
C3, C6, C11, C14, C15, C16, C17: 0.1μF; C025-025X050
C4: 47μF; C025-025X050
C5, C7, C9, C10: 0.1μF; C025-024X044
C8: 0.33μF; C025-024X044
C12, C13: 50pF; C025-025X050
CN1: CON_8P; CON_HRS_DIP_8
CN2: CON_3P; CON_HRS_DIP_3
CN3: CON_2P; CON_HRS_DIP_2
D1, D2, D5: DIODEGENERIC_2; DIODE_2
IC1: MEGA8-P; DIL28-3
IC2: 78XX; TO220-HORZ
IC3: PIC18F14K50
Q1: 16MHz; QS
QF1: 8M10AHC49T; HC49U
R1, R3, R4, R5, R7, R8, R9, R10, R11, R15: 10K; 0204/7
R2: 5K; 0204/7
R6: 22K; 0204/7
R12: 1K; 0204/7
R13, R14: 100; 0204/7
REG1: UPC2933BHB-AZ; 78XX
TC4050BF: HC4050
X2, X3: USD-SOCKET-SH6-SUNHAYATO-CK-40; SUNHAYATO-CK-40

Connections:
+3V3: C4.1, C6.1, C10.1, D1.A, REG1.P$3, TC4050BF.VDD, X2.4 (VCC)
+5V: X3.4 (VCC)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.1, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, CN1.2, CN2.1, CN3.1, IC1.8 (GND), IC1.22 (GND), IC2.2 (GND), IC3.P$11 (VSS), QF1.2, R1.1, R7.1, R10.2, R11.1, REG1.P$2, TC4050BF.VSS, X2.6 (GND), X3.6 (GND)
unnamed: C1.1, IC1.9 (PB6(XTAL1/TOSC1)), Q1.1
unnamed: C2.1, IC1.10 (PB7(XTAL2/TOSC2)), Q1.2
unnamed: CN1.8, CN3.2, IC1.25 (PC2(ADC2)), IC3.P$18 (RB4/AN10/SDI/SDA), R10.1
unnamed: CN1.6, IC1.5 (PD3(INT1)), R3.2, R14.2
unnamed: TC4050BF.P$10 (O4), X2.2 (D3/CS)
unnamed: CN1.3, IC1.26 (PC3(ADC3)), R8.2
unnamed: C14.1, C15.1, IC3.P$15 (RC0/AN4/C12IN+/INT0/VREF+), R11.2, R12.1
unnamed: IC1.17 (PB3(MOSI/OC2)), TC4050BF.P$7 (I3)
unnamed: C3.1, IC3.P$6 (RC4/P1B/C12OUT/SRQ), R1.2, R2.1
unnamed: TC4050BF.P$6 (O3), X2.3 (CMD/DI)
unnamed: D2.K, IC1.18 (PB4(MISO))
unnamed: D2.A, TC4050BF.P$12 (O5)
unnamed: TC4050BF.P$11 (I5), X2.7 (D0/DO)
unnamed: IC1.23 (PC0(ADC0)), IC3.P$3 (RA4/AN3/OSC2/CLKOUT), R6.1, R7.2
unnamed: IC1.19 (PB5(SCK)), TC4050BF.P$5 (I2)
unnamed: IC1.1 (PC6(/RESET)), R4.1
unnamed: TC4050BF.P$4 (O2), X2.5 (CLK/SCK)
unnamed: IC1.16 (PB2(SS/OC1B)), TC4050BF.P$9 (I4)
unnamed: CN1.5, IC1.4 (PD2(INT0)), R5.2, R13.2
unnamed: CN1.4, R2.2
unnamed: IC3.P$7 (RC3/AN7/P1C/C12IN3/PGM), R8.1
unnamed: C13.1, IC3.P$8 (RC6/AN8/SS/T13CK/TI0SCI), QF1.3
unnamed: CN1.7, IC1.3 (PD1(TXD)), R12.2
unnamed: CN2.2, IC3.P$10 (RB7/TX/CK), R9.2
unnamed: C16.1, IC3.P$17 (RC2/AN6/P1D/C121N2-/CVREF/INT2), R13.1
unnamed: C17.1, IC3.P$16 (RC1/AN5/C12IN1-/INT1/VREF-), R14.1, R15.1
RA3/MCLR/VPP: IC3.P$4 (RA3/MCLR/VPP)
VCC: C5.1, C7.1, C9.2, C11.1, C12.1, CN2.3, D1.K, D5.A, IC1.7 (VCC), IC1.20 (AVCC), IC2.3 (OUT), IC3.P$1 (VDD), QF1.1, R3.1, R4.2, R5.1, R9.1, R15.2, REG1.P$1
XVCC: C8.1, CN1.1, D5.K, IC2.1 (IN), R6.2

Notes on the sheet:
8.A/F
3.エンジン温度
5.回転数
6.車速
1.+12V
2.GND
7.ラップカウンタ
TC4050BF
4.メイン

Board: 2 copper layers, 103.8 x 55.9 mm, 47 parts (0 on the bottom side), 30 nets.
